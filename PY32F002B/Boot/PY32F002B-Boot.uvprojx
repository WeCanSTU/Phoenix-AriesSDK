# Keil uVision project PY32F002B-Boot.uvprojx, settings and files
target Boot-HAL (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.1.9
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F002B-Boot-HAL +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F002Bx5,USE_HAL_DRIVER
  c include: .\User;..\..\Sdk\AriesSDK;..\..\Sdk\Py32f002b\Drivers\CMSIS\Include;..\..\Sdk\Py32f002b\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\Sdk\Py32f002b\Drivers\PY32F002B_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ./User/: system_py32f002b.c startup_py32f002bxx.s
  group Application/User
    ./User/: main.c py32f002b_it.c py32f002b_hal_msp.c
  group Drivers/PY32F002B_HAL_Driver
    ../../Sdk/Py32f002b/Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_cortex.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_rcc.c
  group AriesSDK
    ../../Sdk/AriesSDK/Keil-MDK/: AriesSDK-CDC.lib AriesSDK-DFU.lib
    ../../Sdk/AriesSDK/: crc32.c
  group Port
    ../Port/: user_i2c_drv.c user_iap_drv.c
